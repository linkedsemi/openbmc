FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

HDF_EXT = "xsa"
HDF_BASE = "file://"
# HDF_PATH = "run_bmc_20240423_pin_update.xsa"
# HDF_PATH = "run_bmc_v2_I2C_20240711_1.xsa"
# HDF_PATH = "run_bmc_v2_20240813.xsa"

HDF_PATH = "run_bmc_v2_20240815_2_update_sgpio.xsa"
