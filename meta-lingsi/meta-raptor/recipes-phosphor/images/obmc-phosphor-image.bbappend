OBMC_IMAGE_EXTRA_INSTALL:append = " \
    dtc \
    strace \
    memtester \
"
