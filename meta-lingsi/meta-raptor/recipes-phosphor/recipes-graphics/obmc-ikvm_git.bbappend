FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
SRC_URI:append = " file://0001-lingsi-add-kvm-support.patch"
