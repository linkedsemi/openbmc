KBRANCH ?= "linkedsemi-6.18.y"
LINUX_VERSION ?= "6.18.38"
SRCREV = "26ba40f7764e905455b2120be6fd5c10448fd281"
require linux-linkedsemi.inc
